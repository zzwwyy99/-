# Keil uVision project BH-F103.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: BH-F103 +hex
  AfterMake: fromelf --bin --output D:\Desktop\watch_wds\11_02_thread_unittest\Project\Objects\project.bin D:\Desktop\watch_wds\11_02_thread_unittest\Project\Objects\BH-F103.axf
  AfterMake: fromelf  --text  -a -c  --output D:\Desktop\watch_wds\11_02_thread_unittest\Project\Objects\project.dis D:\Desktop\watch_wds\11_02_thread_unittest\Project\Objects\BH-F103.axf
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\Libraries\CMSIS;..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\User;..\watch\cal;..\watch\drive;..\watch\input;..\watch\kal;..\watch\unittest;..\watch\dev\led;..\watch\dev\button;..\watch\dev\i2c;..\watch\dev\display;..\watch\text;..\watch\fontlib;..\watch\dev\beep;..\watch\dev\player;..\watch\game;..\watch\menu;..\watch\message;..\watch\logic;..\watch\thread\include;..\watch\thread\libcpu;..\watch\thread\src;..\watch\thread;..\watch\unitinit;..\watch\dev\rtc;..\watch\dev\dht11
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group STARTUP
    ../Libraries/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/: core_cm3.c system_stm32f10x.c stm32f10x.h
  group FWLIB
    ../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../User/: main.c stm32f10x_it.c
  group DOC
    ../Doc/: readme.txt
  group drive
    ../watch/drive/: drive_gpio.c drive_timer.c drive_usart.c ring_buffer.c drive_i2c.c drive_pwm.c drive_delay.c drive_rtc.c
  group cal
    ../watch/cal/: cal_button.c cal_timer.c cal_led.c cal_i2c.c cal_beep.c
  group kal
    ../watch/kal/: kal_button.c kal_timer.c kal_led.c kal_i2c.c kal_beep.c
  group rtc
    ../watch/dev/rtc/: convert.c rtc_device.c rtc_system.c
  group led_device
    ../watch/dev/led/: led.c led_device.c led_system.c
  group dht11
    ../watch/dev/dht11/: dht11_device.c
  group i2c_device
    ../watch/dev/i2c/: i2c.c i2c_device.c i2c_system.c
  group button_device
    ../watch/dev/button/: button.c button_device.c button_system.c
  group input
    ../watch/input/: button_input.c input_device.c input_system.c input_buffer.c
  group display_device
    ../watch/dev/display/: oled.c display_device.c display_system.c oled_command.c
  group fontlib
    ../watch/fontlib/: ascii_fontlib.c fontlib_manager.c fontlib_system.c
  group text
    ../watch/text/: show_text.c encode_str.c
  group beep
    ../watch/dev/beep/: beep.c beep_device.c beep_system.c
  group player
    ../watch/dev/player/: decode.c player.c player_system.c song_data.h
  group graph
    ../watch/game/: show_graph.c graph_data.c graph_data.h
  group game
    ../watch/game/: role.c role_manager.c role_system.c game.c game_system.c
  group menu
    ../watch/menu/: node_manager.c option.c option_manager.c
  group message
    ../watch/message/: message_manager.c
  group logic
    ../watch/logic/: logic_control.c
  group rtt/ports
    ../watch/thread/: rtconfig.h
    ../watch/thread/libcpu/: context_rvds.s cpuport.c
  group rtt/source
    ../watch/thread/src/: scheduler.c thread.c
  group unitinit
    ../watch/unitinit/: usart_init.c displaydev_init.c
  group unittest
    ../watch/unittest/: usart1_test.c input_test.c led_test.c display_test.c text_test.c beep_test.c decode_test.c player_test.c graph_test.c iterator_test.c game_test.c menu_test.c message_test.c
